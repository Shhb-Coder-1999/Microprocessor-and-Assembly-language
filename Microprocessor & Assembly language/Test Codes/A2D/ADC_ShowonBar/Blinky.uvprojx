# Keil uVision project Blinky.uvprojx, settings and files
target LPC1768 Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: v6Lang=1 v6LangP=1
  c misc: --diag_suppress 550
  c include: C:\Keil_v5\ARM\PACK\Keil\LPC1700_DFP\2.2.0\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./: system_LPC17xx.c
  group Core Code
    ./: core_cm3.c
  group Source Code
    ./: Blinky.c IRQ.c GLCD_LPC1700.c
  group Pictures
    ./: Bg_16bpp_t.c Bg_16bpp_l.c Bg_16bpp_r.c Bg_16bpp_b.c ARM_Ani_16bpp.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 4.3.0
